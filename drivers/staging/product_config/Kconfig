## drivers/staging/product_config/Kconfig
```kconfig
config PRODUCT_NX569
	depends on ARCH_MSM8916
	bool "PRODUCT_NX569J/H Support"
	default n
	---help---
	  Fix version type as PRODUCT_NX569
```
